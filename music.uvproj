# Keil uVision project music.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W104 STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: music +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: music.c music.h
